<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
	<batchBuild>
		<batchDefinition>
			<name>all</name>
			<member>
				<project>ISO7816demo</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>ISO7816demo</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ksdk_platform_lib</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>ksdk_platform_lib</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Release</name>
			<member>
				<project>ISO7816demo</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>ksdk_platform_lib</project>
				<configuration>Release</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Debug</name>
			<member>
				<project>ISO7816demo</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ksdk_platform_lib</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
	<project>
		<path>$WS_DIR$/ISO7816demo.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$/../lib/ksdk_platform_lib/iar/KL03Z4/ksdk_platform_lib.ewp</path>
	</project>
</workspace>